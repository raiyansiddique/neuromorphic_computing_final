v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/neuromorphic_computing_final/schematic/BECI_asghar_synapse.sym} 60 -50 0 0 {name=X1}
