v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/neuromorphic_computing_final/schematic/besrour_neuron_cm.sym} 60 0 0 0 {name=X1}
