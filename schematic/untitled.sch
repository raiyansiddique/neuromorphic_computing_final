v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/neuromorphic_computing_final/schematic/tg.sym} 10 -10 0 0 {name=X1}
C {/home/madvlsi/neuromorphic_computing_final/schematic/memristor_emulator.sym} 140 -10 0 0 {name=X2}
